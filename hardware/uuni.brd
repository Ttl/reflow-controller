# Repository Ttl/reflow-controller

File Readme:

Reflow oven controller for toaster oven.

For more information see:
http://hforsten.com/toaster-oven-reflow-controller.html

Includes code from LUFA:
http://www.fourwalledcubicle.com/LUFA.php

## EAGLE design hardware/uuni.brd

Parts:
C1, C3, C7: 1u; C0603
C2, C4, C8: 100n; C0603
C5, C6: 20p; C0603
C9: 10n; C0603
IC1: FT531JA; SC-74
IC2: MAX31855; SO8
IC3: ATMEGA8U2; TQFP32-08
JP1: M025MM; SCREWTERMINAL-5MM-2
JP2: M02LOCK; 1X02_LOCK
R1, R2: 22; R0603
R3, R4: 10k; R0603
R5: 1k; R0603
RX1: PTC-FUSE-0805; R0805
SV1: MA04-1
SV2: MA03-2
T1: BC817; SOT23-BEC
X1: MINI-USB-SCHIELD-32005-201; 32005-201
Y1: 8Mhz; HC49UP

Connections:
!SS: IC2.6 (!CS), IC3.14 ((!SS!/PCINT0)PB0), R4.1
D+: R2.1, X1.3
D-: R1.1, X1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, IC1.2 (GND), IC2.1 (GND), IC3.3 (GND), IC3.28 (UGND), SV1.4, SV2.6, T1.E, X1.5
MISO: IC2.7 (SO), IC3.17 ((PDO/MISP/PCINT3)PB3), SV2.1
MOSI: IC3.16 ((PDI/MOSI/PCINT12)PB2), SV2.4
unnamed: C5.2, IC3.1 (XTAL1), Y1.2
unnamed: C6.2, IC3.2 (XTAL2(PC0)), Y1.1
unnamed: C9.1, IC2.3 (T+), JP1.1
unnamed: C9.2, IC2.2 (T-), JP1.2
unnamed: IC3.29 (D+), R2.2
unnamed: IC3.30 (D-), R1.2
unnamed: RX1.1, X1.1
unnamed: JP2.2, T1.C
unnamed: R5.1, T1.B
RELAY: IC3.23 ((OC.1A/PCINT8)PC6), R5.2
RST: IC3.24 (!RESET!(PC1/DW)), R3.1, SV2.5
RX: IC3.8 ((RXD1/AIN1/INT2)PD2), SV1.1
SCK: IC2.5 (SCK), IC3.15 ((SCLK/PCINT1)PB1), SV2.3
TX: IC3.9 ((TXD1/INT3)PD3), SV1.2
VCC: C2.1, C3.1, C4.1, C7.1, C8.1, IC1.6 (VOUT), IC2.4 (VCC), IC3.4 (VCC), IC3.27 (UCAP), IC3.31 (UVCC), IC3.32 (AVCC), JP2.1, R3.2, R4.2, SV2.2
VUSB: C1.1, IC1.1 (VIN), IC1.3 (EN), RX1.2, SV1.3

Board: 2 copper layers, 47.0 x 41.0 mm, 25 parts (0 on the bottom side), 22 nets.

## Commit log

2013-09-08 Add schematic and board
2013-09-08 Remove temporary code
2013-12-18 Clean code, less global variables.
2014-05-11 Implement modifying the reflow profile
    Also pretty prints the status output messages
2014-05-11 Clean code
2014-05-11 Restart reflow when program is started
2014-07-15 Add a plot of the target and current temperatures
2026-02-08 Python 3 update and add hold temperature mode
2026-02-08 Firmware fixes
    Cast to correct type before calculation

Notices in the files:
parts and their libraries:
SparkFun-FreqCtrl: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
